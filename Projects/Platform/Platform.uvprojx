# Keil uVision project Platform.uvprojx, settings and files
target LPCXpresso55S69 (6210000::V6.21::ARMCLANG)
  device: LPC55S69JBD100:cm33_core0 NXP
  pack: NXP.LPC55S69_DFP.17.0.0
  cpu: IRAM(0x20000000,0x044000) IRAM2(0x04000000,0x8000) IROM(0x00000000,0x098000) XRAM(0x40100000,0x4000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: image
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ./Board_IO
  memory RVCT4: ROM 0x0 size 0x98000
  memory RVCT6: RAM 0x40100000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x44000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: .\RTE\Device\LPC55S69JBD100_cm33_core0\LPC55S69_cm33_core0_flash.scf
  link misc: --diag_suppress=L6314
  group App
    ./: Platform.c
  group Board
    ./: main.c main.h
  group Board IO
    ./Board_IO/: retarget_stdio.c arduino.c arduino.h
  group MCUXpresso
    ./: LPCXpresso55S69.mex
  group Documentation
    ./: README.md
software components: CMSIS Driver:SPI:Custom 1.0.0, CMSIS Driver:USART:Custom 1.0.0, CMSIS-Compiler:CORE 1.0.0, CMSIS-Compiler:STDERR:Custom 1.0.0, CMSIS-Compiler:STDIN:Custom 1.0.0, CMSIS-Compiler:STDOUT:Custom 1.0.0, CMSIS-View:Event Recorder 1.5.3, CMSIS:CORE 6.0.0, CMSIS:OS Tick:SysTick 1.0.5, CMSIS:RTOS2:Keil RTX5 5.8.0, CMSIS Driver:VIO:Board 2.0.0, Board Support:SDK Project Template:project_template 1.0.0, CMSIS Driver:SPI:flexcomm_spi_cmsis 2.5.0, CMSIS Driver:USART:flexcomm_usart_cmsis 2.4.0, Device:CMSIS:LPC55S69_header 1.0.0, Device:CMSIS:LPC55S69_system 1.0.0, Device:SDK Drivers:clock 2.3.3, Device:SDK Drivers:common 2.4.0, Device:SDK Drivers:dma 2.5.0, Device:SDK Drivers:flexcomm 2.0.2, Device:SDK Drivers:gpio 2.1.7, Device:SDK Drivers:i2c 2.3.3, Device:SDK Drivers:iocon 2.2.0, Device:SDK Drivers:lists 1.0.0, Device:SDK Drivers:power 2.3.0, Device:SDK Drivers:reset 2.1.2, Device:SDK Drivers:spi 2.3.1, Device:SDK Drivers:spi_dma 2.1.1, Device:SDK Drivers:usart 2.8.2, Device:SDK Drivers:usart_adapter 1.0.0, Device:SDK Drivers:usart_dma 2.6.0, Device:SDK Project Template:RTE_Device 1.0.0, Device:SDK Utilities:assert 1.0.0, Device:SDK Utilities:debug_console 1.0.1, Device:SDK Utilities:serial_manager 1.0.1, Device:SDK Utilities:serial_manager_uart 1.0.0, Device:Startup 1.1.0
